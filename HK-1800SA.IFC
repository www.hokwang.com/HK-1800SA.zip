Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: HK-1800SA.IFC
Time: 2022-01-04T08:27:57
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 18SS外殼主體
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: M4×5螺絲
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: SUS出風口B
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 出風口柵門
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 外殼螺絲 (2)
In: Default Storey
PredefinedType: ELEMENT
Name | Material
外殼螺絲 | 0
外殼螺絲 | Steel

# IfcBuildingElementProxy: 底座
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 感應器
In: Default Storey
PredefinedType: ELEMENT; Material: 0
